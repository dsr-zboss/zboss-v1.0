# IAR project zigbee_iar.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Mentor Graphics\M8051EW.i51
  ICC8051.CCDefines: ZB_PLATFORM_8051_SIM; ZB_IAR; ZB_UZ2410; ZB_UZ2410_256; xZB_UZ2410_256_UNBANKED; xC8051F120; ZB_TRACE_LEVEL=2; ZB_DBG_NO_IDLE; ZB_TRAFFIC_DUMP_ON; xZB_ED_ROLE; ZB_SECURITY; x__CLIB_BUILD__; FRMWRI_BUFSIZE=0; SCANF_MAXLINE=0; QSORT_MAXSIZE=0
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: include; osif\include
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  A8051.ADefines: __CLIB_BUILD__
  XLINK.XclFile: osif\8051\mk\iar\lnk51ew_M8051EW_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  ICC8051.CCDefines: __CLIB_BUILD__; FRMWRI_BUFSIZE=50; SCANF_MAXLINE=50; QSORT_MAXSIZE=10
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    osif/8051/mk/iar/: CStartup.s51
    ./: readme.txt
  group C-SPY interface
    $EW_DIR$/8051/src/lib/: debug.s51
  group Compiler support
    $EW_DIR$/8051/src/lib/: cexit.s51 cmain.s51 iar_banked_code_support.s51 iar_char.s51 iar_compare.s51 iar_float.s51 iar_generic_ptr.s51 iar_ieee_float.s51 iar_long.s51 iar_move_long.s51 iar_pointer.s51 iar_setjmp_longjmp.s51 iar_short.s51 iar_stack.s51 iar_stack_enter_leave.s51 iar_stack_enter_leave_dptr.s51 iar_stack_parameter.s51 iar_switch.s51
  group Generic CLIB
    $EW_DIR$/8051/src/lib/clib/: div.c fmod.c ldiv.c mediumrd.c mediumwr.c memchr.c memcmp.c memcpy.c memmove.c memset.c modf.c smallwr.c
  group Low level interface
    osif/8051/mk/iar/: iar_banked_code_support.s51 iar_init_extended1.s51 iar_init_extended2.s51 lnk51ew_C8051F124_banked.xcl lnk51ew_M8051EW_banked.xcl low_level_init.c
  group zigbee_common/aps
    aps/: aps_bind.c aps_commands.c aps_dups.c aps_main.c aps_nwk_confirm.c
  group zigbee_common/common
    common/: zb_address.c zb_bufpool.c zb_bufpool_init.c zb_debug.c zb_ib.c zb_init.c zb_random.c zb_scheduler.c zb_scheduler_init.c zb_time.c
  group zigbee_common/mac
    mac/: mac.c mac_associate.c mac_common.c mac_cr_associate.c mac_cr_coordinator.c mac_cr_data.c mac_data.c mac_fcs.c mac_internal.h mac_routines.c mac_scan.c zb_uz2400.c zb_uz2410.c zb_uz2x_common.c
  group zigbee_common/nwk
    nwk/: nwk_address_assign.c nwk_cr_formation.c nwk_cr_join.c nwk_cr_mesh_routing.c nwk_cr_permit_join.c nwk_cr_route_discovery.c nwk_cr_tree_routing.c nwk_discovery.c nwk_formation.c nwk_internal.h nwk_join.c nwk_main.c nwk_neighbor.c nwk_nlme.c nwk_panid_conflict.c nwk_srouting.c
  group zigbee_common/osif
    osif/8051/: zb_8051_nvram.c zb_8051_serial.c zb_8051_serial_init.c zb_8051_spi.c zb_8051_spi_init.c zb_8051_xram.c zb_mac_transport_8051_direct.c zb_mac_transport_8051_spi.c zb_sysinit.c zb_time_8051.c zb_time_8051_init.c zb_trace_8051.c zb_uz2400_common.c
  group zigbee_common/secur
    secur/: aps_secur.c apsme_secur.c nwk_secur.c secur_ccm.c zdo_secur.c
  group zigbee_common/zdo
    zdo/: af_descriptor.c af_rx.c test_profile.c zdo_app.c zdo_bind_manage.c zdo_channel_manager.c zdo_common.c zdo_common.h zdo_disc_cli.c zdo_disc_srv.c zdo_nwk_manage_cli.c zdo_nwk_manage_srv.c zdo_rx.c
  group zzz_tests
    tests/trace/: trace_test.c
    tests/zdo_startup/: zdo_start_zc.c zdo_start_zr.c
  group zzz_tests/tp_aps_bv_33_zed1
    tests/certification/TP_APS_BV-33-I/: tp_aps_bv_33_i_gZED1.c
  group zzz_tests/tp_aps_bv_33_zed2
    tests/certification/TP_APS_BV-33-I/: tp_aps_bv_33_i_gZED2.c
  group zzz_tests/tp_pro_bv_27_zed1
    tests/certification/TP_PRO_BV-27/: tp_pro_bv_27_DUTZED1.c
  group zzz_tests/tp_pro_bv_27_zed2
    tests/certification/TP_PRO_BV-27/: tp_pro_bv_27_DUTZED2.c
  group zzz_tests/tp_pro_bv_28_zed
    tests/certification/TP_PRO_BV-28/: tp_pro_bv_28_gZED.c
  group zzz_tests/tp_zdo_bv_01_zed
    tests/certification/TP_ZDO_BV-01/: tp_zdo_bv_01_zed.c
  group zzz_tests/tp_zdo_bv_03_zed1
    tests/certification/TP_ZDO_BV-03/: TP_ZDO_BV_03_ZED1.c
  group zzz_tests/tp_zdo_bv_03_zed2
    tests/certification/TP_ZDO_BV-03/: TP_ZDO_BV_03_ZED2.c
  group zzz_tests/tp_zdo_bv_05_zed1
    tests/certification/TP_ZDO_BV-05/: TP_ZDO_BV_05_ZED1.c
  group zzz_tests/tp_zdo_bv_05_zed2
    tests/certification/TP_ZDO_BV-05/: TP_ZDO_BV_05_ZED2.c
  group zzz_tests/tp_zdo_bv_06_zed1
    tests/certification/TP_ZDO_BV-06/: tp_zdo_bv_06_gZED1.c
  group zzz_tests/tp_zdo_bv_06_zed2
    tests/certification/TP_ZDO_BV-06/: tp_zdo_bv_06_gZED2.c
  group zzz_tests/zdo_start_secur_zed
    tests/zdo_start_secur/: zdo_start_sec_ze.c
  group zzz_tests/zdo_startup_zed
    tests/zdo_startup/: zdo_start_ze.c
