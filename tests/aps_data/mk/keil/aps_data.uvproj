# Keil uVision project aps_data.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F124 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: aps_data +hex
  c flags: Optimize=9
  c define: ZB_PLATFORM_8051_SIM  KEIL C8051F120 FIRST_TEST xZB_TRACE_LEVEL=4
  c include: ..\..\..\..\include;..\..\..\..\osif\include
  group Source Group 1
    ./: STARTUP.A51 L51_BANK.A51
    ../../../../build/: zigbee.LIB
    ../../: aps_data_test.c
