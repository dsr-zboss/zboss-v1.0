# Keil uVision project 8051_spi_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F124 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: 8051_spi_test +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG  ZB_PLATFORM_8051_SIM ZB_TRACE_MASK=-1 ZB_TRACE_LEVEL=4 KEIL C8051F120
  c include: ..\..\..\..\include;..\..\..\..\osif\include
  group Source Group 1
    ./: STARTUP.A51
    ../../: spi_test.c
    ../../../../build/: zigbee.LIB
