# Keil uVision project zb_bi.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F124 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: zb_bi
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c func.c func2.c
    C:/Keil/C51/LIB/: L51_BANK.A51
