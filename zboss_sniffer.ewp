# IAR project zboss_sniffer.ewp, settings and files
configuration SmartRf05Eb-Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: ZB_SNIFFER; ZB_SNIFFER_SERIAL_TRACE; ZB_PLATFORM_8051_SIM; ZB_CC25XX; ZB_IAR
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: include; osif\include; devtools\sniffer; devtools\sniffer\usb\common; devtools\sniffer\usb\common\cc8051; devtools\sniffer\usb\class_cdc; devtools\sniffer\usb\library; devtools\sniffer\usb\library\cc2531; devtools\sniffer\usb\targets\cc2531_dongle; devtools\sniffer\usb\targets\common; devtools\sniffer\usb\targets\interface; devtools\sniffer\usb\utils
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Smartrf05Eb-Release (8051)
  as the first configuration, except:
  ICC8051.CCOptLevel: 3
configuration CC2531-USB-Dongle-Debug (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531F256.i51
  ICC8051.CCDefines: ZB_SNIFFER; ZB_SNIFFER_USB_TRACE; ZB_PLATFORM_8051_SIM; ZB_CC25XX; ZB_IAR
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2531F256.xcl
configuration CC2531-USB-Dongle-Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: as above
  ICC8051.CCDefines: as above
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: as above
  group mac
    mac/: zb_cc25xx.c zb_cc25xx_common.c
  group osif/8051
    osif/8051/: zb_8051_serial.c zb_8051_serial_init.c zb_time_8051_init.c
  group sniffer
    devtools/sniffer/: zb_sniffer.c zb_sniffer_tools.c
  group usb/class_cdc
    devtools/sniffer/usb/class_cdc/: usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_firmware_library_config.c usb_uart.c
  group usb/common
    devtools/sniffer/usb/common/: clock.c hal_int.c hal_mcu.c
  group usb/library
    devtools/sniffer/usb/library/: usb_descriptor_parser.c usb_framework.c usb_standard_requests.c
  group usb/library/cc2531
    devtools/sniffer/usb/library/cc2531/: hal_enter_pm.s51 usb_interrupt.c usb_suspend.c
  group util
    devtools/sniffer/usb/utils/: util_buffer.c
