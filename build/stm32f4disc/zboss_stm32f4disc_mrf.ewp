# IAR project zboss_stm32f4disc_mrf.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ZB_CORTEXM4; cortexm4; USE_STDPERIPH_DRIVER; STM32F4_DISCOVERY; ZB_MRF24J40; ZB_TRANSPORT_CORTEXM4_UART; ZB_TRANSPORT_CORTEXM4_DATA_SPI; ZB_TRANSPORT_CORTEXM4; ZB_LITTLE_ENDIAN; xZB_DEBUG_BUFFERS
  ICCARM.CCIncludePath2: ..\..\include; ..\..\osif\include; ..\..\osif\cortexm4\board; ..\..\osif\cortexm4\SPL_inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: zboss_stm32f4disc_mrf.srec
  ILINK.IlinkOutputFile: zboss_stm32f4disc_mrf.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application/zdo_startup
    ../../tests/zdo_startup/: interrupt_test.c zdo_start_zc.c zdo_start_zr.c
  group aps
    ../../aps/: aps_bind.c aps_commands.c aps_dups.c aps_internal.h aps_main.c aps_nwk_confirm.c
  group common
    ../../common/: zb_address.c zb_bufpool.c zb_bufpool_init.c zb_debug.c zb_ib.c zb_init.c zb_random.c zb_scheduler.c zb_scheduler_init.c zb_time.c zb_trace.c
  group mac
    ../../mac/: mac.c mac_associate.c mac_common.c mac_cr_associate.c mac_cr_coordinator.c mac_cr_data.c mac_data.c mac_fcs.c mac_routines.c mac_scan.c zb_mrf24j40.c
  group nwk
    ../../nwk/: nwk_address_assign.c nwk_cr_formation.c nwk_cr_join.c nwk_cr_mesh_routing.c nwk_cr_permit_join.c nwk_cr_route_discovery.c nwk_cr_tree_routing.c nwk_discovery.c nwk_formation.c nwk_internal.h nwk_join.c nwk_main.c nwk_neighbor.c nwk_nlme.c nwk_panid_conflict.c
  group osif/cortexm4
    ../../osif/cortexm4/: HardFaultHandlerASM.S HardFaultHandlerC.c zb_cortexm4_exti.c zb_cortexm4_spi.c zb_cortexm4_time.c zb_cortexm4_usart.c zb_trace_cortexm4.c zb_transport_cortexm4.c
  group osif/cortexm4/board
    ../../osif/cortexm4/board/: startup_stm32f40_41xxx_iar.s
  group osif/cortexm4/SPL_src
    ../../osif/cortexm4/SPL_src/: misc.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c
  group secur
    ../../secur/: aps_secur.c apsme_secur.c mac_secur.c nwk_secur.c secur_ccm.c zdo_secur.c
  group zdo
    ../../zdo/: af_descriptor.c af_rx.c test_profile.c zdo_app.c zdo_bind_manage.c zdo_channel_manager.c zdo_common.c zdo_common.h zdo_disc_cli.c zdo_disc_srv.c zdo_nwk_manage_cli.c zdo_nwk_manage_srv.c zdo_rx.c
