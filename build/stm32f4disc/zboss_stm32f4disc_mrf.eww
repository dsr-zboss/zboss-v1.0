<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\zboss_stm32f4disc_mrf.ewp</path>
  </project>
  <batchBuild/>
</workspace>


